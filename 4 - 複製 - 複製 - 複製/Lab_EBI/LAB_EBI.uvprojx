# Keil uVision project LAB_EBI.uvprojx, settings and files
target LAB_EBI (5060020::V5.06 (build 20)::ARMCC)
  device: NANO130KE3BN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.5
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: LAB_EBI
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\@L.bin"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group SRC
    ./: main.c tft.c font16.c HID.lib img2.c
software components: CMSIS:CORE 5.3.0, Device:Driver:CLK 3.02.002, Device:Driver:EBI 3.02.002, Device:Driver:GPIO 3.02.002, Device:Driver:SYS 3.02.002, Device:Driver:UART 3.02.002, Device:Driver:USB 3.02.002, Device:Startup 0.00.001
